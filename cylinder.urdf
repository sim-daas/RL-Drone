Commit message: obstacle addition and movement done

File: cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link base_link: mass 0.2 -> 0.0002
